# Keil uVision project Voilier.uvprojx, settings and files
target Simulé (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Voilier_simul
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include;..\MesDrivers\Include;..\MesDrivers\Source;..\Services\Include;..\Services\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sources
    ./Sources/: main.c
  group Drivers
    ../MesDrivers/Source/: MyGPIO.c MyTimer.c Lib_Com_Periph_2022.lib UART.c
  group Include
    ../MesDrivers/Include/: MyGPIO.h MyI2C.h MySPI.h MyTimer.h UART.h
    ../Services/Include/: Accelerometre.h Ecoute.h Girouette.h Voiles.h Plateau.h
  group Services
    ../Services/Source/: Accelerometre.c Ecoute.c Girouette.c Voiles.c Plateau.c
target Réel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: LED_reel
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include;..\MesDrivers\Include;..\Services\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
